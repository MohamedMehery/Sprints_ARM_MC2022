# Keil uVision project Blinking_led.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinking_led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\APPLICATION\Inc;.\HAL\Inc;.\LIBRARIES\Config\Inc;.\LIBRARIES\Common;.\MCAL\Inc;.\SERVICE\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./APPLICATION/: App.c
    ./APPLICATION/Inc/: App.h
    ./HAL/: Led.c Button.c
    ./HAL/Inc/: Led.h Button.h
    ./LIBRARIES/Config/: Dio_Lcfg.c Gpt_Lcfg.c IntCtrl_Lcfg.c Port_Lcfg.c
    ./LIBRARIES/Config/Inc/: Port_Cfg.h IntCtrl_Cfg.h Gpt_Cfg.h Dio_Cfg.h
    ./LIBRARIES/Common/: Compiler.h Macros.h Mcu_Hw.h Platform_Types.h Std_Types.h
    ./MCAL/: Dio.c Gpt.c IntCtrl.c Port.c
    ./MCAL/Inc/: Dio.h Dio_regs.h Dio_Types.h Gpt.h Gpt_regs.h Gpt_Types.h IntCtrl.h Port.h Port_regs.h Port_Types.h
    ./SERVICE/: Input.c Blink.c
    ./SERVICE/Inc/: Service_Types.h Input.h Blink.h
software components: CMSIS:CORE 5.6.0, Compiler:Event Recorder 1.5.1, Device:Startup 1.0.1
